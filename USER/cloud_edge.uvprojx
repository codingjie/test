# Keil uVision project cloud_edge.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: cloud_edge +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_FWLib\inc;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\adc;..\HARDWARE\OLED;..\HARDWARE\MOTOR;..\HARDWARE\BEEP;..\HARDWARE\ASRPRO;..\HARDWARE\DS18B20;..\HARDWARE\KEY;..\HARDWARE\LD2450;..\HARDWARE\SG90;..\HARDWARE\SR501;..\SYSTEM\sys
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s
  group HARDWARE
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/ASRPRO/: asrpro.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LD2450/: ld2450.c
    ../HARDWARE/SG90/: sg90.c
    ../HARDWARE/SR501/: sr501.c
  group FWlib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/adc/: adc.c
    ../SYSTEM/sys/: sys.c
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
