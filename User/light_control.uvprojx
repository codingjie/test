# Keil uVision project light_control.uvprojx, settings and files
target LightControl (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: light_control +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,
  c include: ..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\User;..\Hardware\flash;..\Hardware\led;..\Hardware\usart;..\FreeRTOS\include;..\FreeRTOS\port\RVDS\ARM_CM4F;..\Hardware\exti;..\Hardware\key;..\Hardware\beep;..\Hardware\cs100a;..\Hardware\DHT11;..\Hardware\dwt_delay;..\Hardware\ESP8266;..\Hardware\exti;..\Hardware\iic;..\Hardware\oled;..\Hardware\photoresistor;..\Hardware\systick;..\Hardware\timer;..\Hardware\usart_printf
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group USER
    ./: main.c stm32f4xx_it.c FreeRTOSConfig.h
  group HARDWARE
    ../Hardware/flash/: bsp_spi_flash.c
    ../Hardware/led/: bsp_led.c
    ../Hardware/usart/: bsp_debug_usart.c
    ../Hardware/key/: bsp_key.c
    ../Hardware/exti/: bsp_exti.c
    ../Hardware/beep/: bsp_beep.c
    ../Hardware/cs100a/: bsp_cs100a.c
    ../Hardware/DHT11/: bsp_dht11.c
    ../Hardware/dwt_delay/: core_delay.c
    ../Hardware/ESP8266/: bsp_esp8266.c bsp_esp8266_test.c
    ../Hardware/iic/: bsp_iic_debug.c
    ../Hardware/oled/: bsp_oled_debug.c
    ../Hardware/photoresistor/: bsp_photoresistor.c
    ../Hardware/timer/: bsp_timer_encoder.c
    ../Hardware/usart_printf/: usart_printf.c
  group FREERTOS
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
